options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: simulator_fsk
    output_language: python
  states: {}

blocks:
- name: R_max
  id: variable
  parameters:
    value: 3e8/2/delta_freq
  states: {}
- name: blocks_per_tag
  id: variable
  parameters:
    value: 2**17
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: '1000000000'
  states: {}
- name: decimator_fac
  id: variable
  parameters:
    value: 2**7
  states: {}
- name: delaytime
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '0'
    step: '1'
    stop: '50'
    value: '0'
  states: {}
- name: delta_freq
  id: variable
  parameters:
    value: samp_rate/4
  states: {}
- name: fft_size
  id: variable
  parameters:
    value: '512'
  states: {}
- name: freq_res
  id: variable
  parameters:
    value: samp_rate/2/blocks_per_tag
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '0'
    step: '1'
    stop: '70'
    value: '70'
  states: {}
- name: lo
  id: variable
  parameters:
    value: '2033000000'
  states: {}
- name: min_output_buffer
  id: variable
  parameters:
    value: 2*(blocks_per_tag*samp_per_freq*2)
  states: {}
- name: protect
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '0'
    step: '1'
    stop: '100'
    value: '0'
  states: {}
- name: q
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: range_time
  id: variable
  parameters:
    value: '10'
  states: {}
- name: range_value
  id: variable_qtgui_range
  parameters:
    label: range
    start: '0'
    step: '1'
    stop: '120'
    value: '10'
  states: {}
- name: samp_discard
  id: variable
  parameters:
    value: '0'
  states: {}
- name: samp_per_freq
  id: variable
  parameters:
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1500000'
  states: {}
- name: threshold
  id: variable_qtgui_range
  parameters:
    label: Threshold Peak detector
    start: '-200'
    step: '1'
    stop: '1000'
    value: '-120'
  states: {}
- name: v_res
  id: variable
  parameters:
    value: freq_res*3e8/2/center_freq
  states: {}
- name: value_range
  id: variable_qtgui_range
  parameters:
    label: range
    start: '0'
    step: '1'
    stop: R_max+R_max/2
    value: '10'
  states: {}
- name: velocity
  id: variable_qtgui_range
  parameters:
    start: '-30'
    step: '1'
    stop: '30'
    value: '20'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_agc_xx_0_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters:
    minoutbuf: min_output_buffer
  states: {}
- name: blocks_multiply_conjugate_cc_0_0
  id: blocks_multiply_conjugate_cc
  parameters:
    minoutbuf: min_output_buffer
  states: {state: disabled}
- name: blocks_multiply_conjugate_cc_1
  id: blocks_multiply_conjugate_cc
  parameters:
    minoutbuf: min_output_buffer
  states: {}
- name: blocks_tagged_stream_multiply_length_0
  id: blocks_tagged_stream_multiply_length
  parameters:
    c: 1.0/decimator_fac
    lengthtagname: '"packet_len"'
    minoutbuf: min_output_buffer
    type: complex
  states: {}
- name: blocks_tagged_stream_multiply_length_0_0
  id: blocks_tagged_stream_multiply_length
  parameters:
    c: 1.0/decimator_fac
    lengthtagname: '"packet_len"'
    minoutbuf: min_output_buffer
    type: complex
  states: {}
- name: blocks_tagged_stream_multiply_length_0_0_0
  id: blocks_tagged_stream_multiply_length
  parameters:
    c: 1.0/decimator_fac
    lengthtagname: '"packet_len"'
    minoutbuf: min_output_buffer
    type: complex
  states: {state: disabled}
- name: blocks_tagged_stream_multiply_length_0_1
  id: blocks_tagged_stream_multiply_length
  parameters:
    c: 1.0/decimator_fac
    lengthtagname: '"packet_len"'
    minoutbuf: min_output_buffer
    type: complex
  states: {state: disabled}
- name: blocks_udp_sink_0_0
  id: blocks_udp_sink
  parameters:
    eof: 'True'
    ipaddr: localhost
    port: '3333'
    psize: '1472'
    type: complex
    vlen: '1'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 1e3
    decim: '6096'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 1e3
    win: firdes.WIN_HAMMING
  states: {}
- name: pluto_sink_0
  id: pluto_sink
  parameters:
    attenuation: '0'
    auto_filter: 'True'
    bandwidth: q
    buffer_size: '0x8000'
    cyclic: 'False'
    filter: ''
    frequency: lo
    samplerate: samp_rate
    uri: ip:pluto.local
  states: {}
- name: pluto_source_0
  id: pluto_source
  parameters:
    auto_filter: 'True'
    bandwidth: q
    bbdc: 'True'
    buffer_size: '0x8000'
    filter: ''
    frequency: lo
    gain: '"manual"'
    manual_gain: gain
    quadrature: 'False'
    rfdc: 'False'
    samplerate: samp_rate
    uri: ip:pluto.local
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate/decimator_fac/2
    fc: '0'
    fftsize: blocks_per_tag/decimator_fac
    name: RX RADAR
    showports: 'True'
    type: complex
  states: {state: disabled}
- name: qtgui_sink_x_1
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    showports: 'True'
    type: complex
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    showports: 'True'
    type: complex
  states: {}
- name: radar_estimator_fsk_0
  id: radar_estimator_fsk
  parameters:
    center_freq: center_freq
    delta_freq: delta_freq
    push_power: 'True'
  states: {}
- name: radar_estimator_fsk_0_0
  id: radar_estimator_fsk
  parameters:
    center_freq: center_freq
    delta_freq: delta_freq
    push_power: 'False'
  states: {state: disabled}
- name: radar_find_max_peak_c_0
  id: radar_find_max_peak_c
  parameters:
    cut_max_freq: 'False'
    len_key: '"packet_len"'
    samp_protect: '0'
    samp_rate: samp_rate/decimator_fac/2
    threshold: threshold
  states: {state: disabled}
- name: radar_os_cfar_c_0
  id: radar_os_cfar_c
  parameters:
    len_key: '"packet_len"'
    merge_consecutive: 'True'
    minoutbuf: min_output_buffer
    mult_threshold: '30'
    rel_threshold: '0.9'
    samp_compare: '15'
    samp_protect: protect
    samp_rate: samp_rate/2/decimator_fac
  states: {}
- name: radar_print_results_0
  id: radar_print_results
  parameters:
    filename: '"test.txt"'
    store_msg: 'True'
  states: {state: disabled}
- name: radar_print_results_0_0
  id: radar_print_results
  parameters:
    filename: '"test.txt"'
    store_msg: 'False'
  states: {state: disabled}
- name: radar_qtgui_scatter_plot_0
  id: radar_qtgui_scatter_plot
  parameters:
    axis_x: '-10,2000'
    axis_y: '-40,40'
    interval: '500'
    label_x: '''range'''
    label_y: '''velocity'''
  states: {}
- name: radar_qtgui_scatter_plot_0_0
  id: radar_qtgui_scatter_plot
  parameters:
    axis_x: '-10,2000'
    axis_y: '-30,30'
    interval: '250'
    label: TRACING
    label_x: '''range'''
    label_y: '''velocity'''
  states: {state: disabled}
- name: radar_qtgui_time_plot_0
  id: radar_qtgui_time_plot
  parameters:
    axis_y: '-10,10'
    interval: '1'
    label_y: '''velocity'''
    range_time: '100'
  states: {}
- name: radar_qtgui_time_plot_0_0
  id: radar_qtgui_time_plot
  parameters:
    axis_y: 0,2000
    interval: '100'
    label_y: '''range'''
    range_time: '10'
  states: {}
- name: radar_qtgui_time_plot_0_0_0
  id: radar_qtgui_time_plot
  parameters:
    axis_y: 0,200
    interval: '250'
    label: '"TRACKING"'
    label_y: '''range'''
    range_time: range_time
  states: {state: disabled}
- name: radar_qtgui_time_plot_0_1
  id: radar_qtgui_time_plot
  parameters:
    axis_y: '-5,5'
    interval: '250'
    label: '"TRACKING"'
    label_y: '''velocity'''
    range_time: range_time
  states: {state: disabled}
- name: radar_signal_generator_fsk_c_0
  id: radar_signal_generator_fsk_c
  parameters:
    amplitude: '10'
    blocks_per_tag: blocks_per_tag
    freq_high: delta_freq/2
    freq_low: '-delta_freq/2'
    len_key: '"packet_len"'
    minoutbuf: min_output_buffer
    samp_per_freq: samp_per_freq
    samp_rate: samp_rate
  states: {}
- name: radar_split_fsk_cc_0
  id: radar_split_fsk_cc
  parameters:
    len_key: '"packet_len"'
    minoutbuf: min_output_buffer
    samp_discard: samp_discard
    samp_per_freq: samp_per_freq
  states: {}
- name: radar_split_fsk_cc_0_0
  id: radar_split_fsk_cc
  parameters:
    len_key: '"packet_len"'
    minoutbuf: min_output_buffer
    samp_discard: samp_discard
    samp_per_freq: samp_per_freq
  states: {state: disabled}
- name: radar_tracking_singletarget_0
  id: radar_tracking_singletarget
  parameters:
    filter: '"particle"'
    num_particle: '100'
    std_accel_sys: '0.1'
    std_range_meas: '1'
    std_velocity_meas: v_res
    threshold_lost: '3'
    threshold_track: '0.001'
  states: {state: disabled}
- name: radar_ts_fft_cc_0
  id: radar_ts_fft_cc
  parameters:
    len_key: ' "packet_len"'
    packet_len: blocks_per_tag/decimator_fac
  states: {}
- name: radar_ts_fft_cc_0_0
  id: radar_ts_fft_cc
  parameters:
    len_key: ' "packet_len"'
    packet_len: blocks_per_tag/decimator_fac
  states: {}
- name: radar_ts_fft_cc_0_0_0
  id: radar_ts_fft_cc
  parameters:
    len_key: ' "packet_len"'
    packet_len: blocks_per_tag/decimator_fac
  states: {state: disabled}
- name: radar_ts_fft_cc_0_1
  id: radar_ts_fft_cc
  parameters:
    len_key: ' "packet_len"'
    packet_len: blocks_per_tag/decimator_fac
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: decimator_fac
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: decimator_fac
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0_0
  id: rational_resampler_xxx
  parameters:
    decim: decimator_fac
    interp: '1'
    taps: ''
    type: ccc
  states: {state: disabled}
- name: rational_resampler_xxx_0_1
  id: rational_resampler_xxx
  parameters:
    decim: decimator_fac
    interp: '1'
    taps: ''
    type: ccc
  states: {state: disabled}

connections:
- [analog_agc_xx_0, '0', blocks_multiply_conjugate_cc_1, '0']
- [analog_agc_xx_0_0, '0', blocks_multiply_conjugate_cc_1, '1']
- [blocks_multiply_conjugate_cc_0, '0', radar_os_cfar_c_0, '0']
- [blocks_multiply_conjugate_cc_0_0, '0', radar_find_max_peak_c_0, '0']
- [blocks_multiply_conjugate_cc_1, '0', low_pass_filter_0, '0']
- [blocks_multiply_conjugate_cc_1, '0', radar_split_fsk_cc_0, '0']
- [blocks_tagged_stream_multiply_length_0, '0', radar_ts_fft_cc_0, '0']
- [blocks_tagged_stream_multiply_length_0_0, '0', qtgui_sink_x_0, '0']
- [blocks_tagged_stream_multiply_length_0_0, '0', radar_ts_fft_cc_0_0, '0']
- [blocks_tagged_stream_multiply_length_0_0_0, '0', radar_ts_fft_cc_0_0_0, '0']
- [blocks_tagged_stream_multiply_length_0_1, '0', radar_ts_fft_cc_0_1, '0']
- [low_pass_filter_0, '0', blocks_udp_sink_0_0, '0']
- [pluto_source_0, '0', analog_agc_xx_0, '0']
- [radar_estimator_fsk_0, Msg out, radar_print_results_0, Msg in]
- [radar_estimator_fsk_0, Msg out, radar_qtgui_scatter_plot_0, Msg in]
- [radar_estimator_fsk_0, Msg out, radar_qtgui_time_plot_0, Msg in]
- [radar_estimator_fsk_0, Msg out, radar_qtgui_time_plot_0_0, Msg in]
- [radar_estimator_fsk_0_0, Msg out, radar_tracking_singletarget_0, Msg in]
- [radar_find_max_peak_c_0, Msg out, radar_estimator_fsk_0_0, Msg in]
- [radar_os_cfar_c_0, Msg out, radar_estimator_fsk_0, Msg in]
- [radar_signal_generator_fsk_c_0, '0', analog_agc_xx_0_0, '0']
- [radar_signal_generator_fsk_c_0, '0', pluto_sink_0, '0']
- [radar_signal_generator_fsk_c_0, '0', qtgui_sink_x_1, '0']
- [radar_signal_generator_fsk_c_0, '0', qtgui_waterfall_sink_x_0, '0']
- [radar_split_fsk_cc_0, '0', rational_resampler_xxx_0, '0']
- [radar_split_fsk_cc_0, '1', rational_resampler_xxx_0_0, '0']
- [radar_split_fsk_cc_0_0, '0', rational_resampler_xxx_0_1, '0']
- [radar_split_fsk_cc_0_0, '1', rational_resampler_xxx_0_0_0, '0']
- [radar_tracking_singletarget_0, Msg out, radar_print_results_0_0, Msg in]
- [radar_tracking_singletarget_0, Msg out, radar_qtgui_scatter_plot_0_0, Msg in]
- [radar_tracking_singletarget_0, Msg out, radar_qtgui_time_plot_0_0_0, Msg in]
- [radar_tracking_singletarget_0, Msg out, radar_qtgui_time_plot_0_1, Msg in]
- [radar_ts_fft_cc_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [radar_ts_fft_cc_0_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [radar_ts_fft_cc_0_0_0, '0', blocks_multiply_conjugate_cc_0_0, '0']
- [radar_ts_fft_cc_0_1, '0', blocks_multiply_conjugate_cc_0_0, '1']
- [rational_resampler_xxx_0, '0', blocks_tagged_stream_multiply_length_0, '0']
- [rational_resampler_xxx_0_0, '0', blocks_tagged_stream_multiply_length_0_0, '0']
- [rational_resampler_xxx_0_0_0, '0', blocks_tagged_stream_multiply_length_0_0_0, '0']
- [rational_resampler_xxx_0_1, '0', blocks_tagged_stream_multiply_length_0_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.2.0
