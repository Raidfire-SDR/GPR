<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>Radar_Data_Client</value></param>
<param><key>author</key><value>LFC</value></param>
<param><key>description</key><value>Client to receive processed radar data, providing live graphical feedback and recording of a datafile for offline processing</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>Radar Data Client</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>C</value></param>
<param><key>value</key><value>299792458</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>R_max</value></param>
<param><key>value</key><value>3e8/2/delta_freq</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>WL</value></param>
<param><key>value</key><value>C/samp_rate</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>blocks_per_tag</value></param>
<param><key>value</key><value>2**17</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>center_freq</value></param>
<param><key>value</key><value>1000000000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>decim</value></param>
<param><key>value</key><value>512</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>decimator_fac</value></param>
<param><key>value</key><value>2**7</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>delta_freq</value></param>
<param><key>value</key><value>samp_rate/4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fft_size</value></param>
<param><key>value</key><value>1024</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq_res</value></param>
<param><key>value</key><value>samp_rate/2/blocks_per_tag</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>lo</value></param>
<param><key>value</key><value>2033000000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>min_output_buffer</value></param>
<param><key>value</key><value>2*(blocks_per_tag*samp_per_freq*2)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_discard</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_per_freq</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>1500000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>v_res</value></param>
<param><key>value</key><value>freq_res*3e8/2/center_freq</value></param>
</block>
<block>
<key>variable_qtgui_push_button</key>
<param><key>id</key><value>variable_qtgui_push_button_0</value></param>
<param><key>value</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>pressed</key><value>epy_module_0</value></param>
<param><key>released</key><value>0</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>blocks_complex_to_interleaved_short</key>
<param><key>id</key><value>blocks_complex_to_interleaved_short_0</value></param>
<param><key>vector_output</key><value>False</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0_0</value></param>
<param><key>vlen</key><value>fft_size</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>c:\kandar\RadarData\radar.bin</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>Z:\data\radar.bin</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>fft_size</value></param>
</block>
<block>
<key>blocks_udp_source</key>
<param><key>id</key><value>blocks_udp_source_0</value></param>
<param><key>ipaddr</key><value>localhost</value></param>
<param><key>eof</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>psize</key><value>1472</value></param>
<param><key>port</key><value>3333</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_items</key><value>fft_size</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0_0_0_1</value></param>
<param><key>fft_size</key><value>fft_size</value></param>
<param><key>forward</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>nthreads</key><value>8</value></param>
<param><key>shift</key><value>False</value></param>
<param><key>window</key><value>window.blackmanharris(fft_size)</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0</value></param>
<param><key>cutoff_freq</key><value>1e3</value></param>
<param><key>decim</key><value>decim</value></param>
<param><key>_enabled</key><value>2</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>1e3</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>parameter_0</value></param>
<param><key>value</key><value>149</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_0</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_HORIZ</value></param>
<param><key>type</key><value>short</value></param>
</block>
<block>
<key>qtgui_time_raster_sink_x</key>
<param><key>id</key><value>qtgui_time_raster_sink_x_0_0</value></param>
<param><key>color1</key><value>1</value></param>
<param><key>name</key><value>"Mag"</value></param>
<param><key>ncols</key><value>fft_size</value></param>
<param><key>nrows</key><value>64</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
<param><key>update_time</key><value>0.01</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate/decim</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>fft_size</value></param>
<param><key>color1</key><value>1</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>radar_estimator_fsk</key>
<param><key>id</key><value>radar_estimator_fsk_0</value></param>
<param><key>center_freq</key><value>center_freq</value></param>
<param><key>delta_freq</key><value>delta_freq</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>push_power</key><value>True</value></param>
</block>
<block>
<key>radar_os_cfar_c</key>
<param><key>id</key><value>radar_os_cfar_c_0</value></param>
<param><key>samp_compare</key><value>15</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>merge_consecutive</key><value>True</value></param>
<param><key>minoutbuf</key><value>min_output_buffer</value></param>
<param><key>mult_threshold</key><value>30</value></param>
<param><key>len_key</key><value>"packet_len"</value></param>
<param><key>samp_protect</key><value>0</value></param>
<param><key>rel_threshold</key><value>0.9</value></param>
<param><key>samp_rate</key><value>samp_rate/2/decimator_fac</value></param>
</block>
<block>
<key>radar_qtgui_scatter_plot</key>
<param><key>id</key><value>radar_qtgui_scatter_plot_0</value></param>
<param><key>axis_x</key><value>-10,2000</value></param>
<param><key>axis_y</key><value>-40,40</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>label_x</key><value>'range'</value></param>
<param><key>label_y</key><value>'velocity'</value></param>
<param><key>interval</key><value>500</value></param>
</block>
<block>
<key>radar_qtgui_time_plot</key>
<param><key>id</key><value>radar_qtgui_time_plot_0</value></param>
<param><key>axis_y</key><value>-10,10</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>label_y</key><value>'velocity'</value></param>
<param><key>range_time</key><value>100</value></param>
<param><key>interval</key><value>1</value></param>
</block>
<block>
<key>radar_qtgui_time_plot</key>
<param><key>id</key><value>radar_qtgui_time_plot_0_0</value></param>
<param><key>axis_y</key><value>0,200</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>label_y</key><value>'range'</value></param>
<param><key>range_time</key><value>10</value></param>
<param><key>interval</key><value>100</value></param>
</block>
<connection><source_block_id>blocks_complex_to_interleaved_short_0</source_block_id><sink_block_id>qtgui_number_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0_0</source_block_id><sink_block_id>blocks_vector_to_stream_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>blocks_complex_to_interleaved_short_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0_1</source_block_id><sink_block_id>fft_vxx_0_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_udp_source_0</source_block_id><sink_block_id>blocks_file_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_udp_source_0</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0_0</source_block_id><sink_block_id>qtgui_time_raster_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0_0_0_1</source_block_id><sink_block_id>blocks_complex_to_mag_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>blocks_stream_to_vector_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radar_estimator_fsk_0</source_block_id><sink_block_id>radar_qtgui_scatter_plot_0</sink_block_id><source_key>Msg out</source_key><sink_key>Msg in</sink_key></connection>
<connection><source_block_id>radar_estimator_fsk_0</source_block_id><sink_block_id>radar_qtgui_time_plot_0</sink_block_id><source_key>Msg out</source_key><sink_key>Msg in</sink_key></connection>
<connection><source_block_id>radar_estimator_fsk_0</source_block_id><sink_block_id>radar_qtgui_time_plot_0_0</sink_block_id><source_key>Msg out</source_key><sink_key>Msg in</sink_key></connection>
<connection><source_block_id>radar_os_cfar_c_0</source_block_id><sink_block_id>radar_estimator_fsk_0</sink_block_id><source_key>Msg out</source_key><sink_key>Msg in</sink_key></connection>
</flow_graph>
